## lkfs/Kconfig
```kconfig
config LKFS_FS
	tristate "Lake fs support"
	help
	  Lake is a standard Linux file system for hard disks.
```
